options:
  parameters:
    generate_options: qt_gui
    id: assignment
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
    bus_sink: 'false'
    bus_source: 'false'
    coordinate: ['1176', '160.0']
    rotation: '0'
    state: enabled
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: output_bytes.bin
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[1,2,3,4,5,6,7,8,9,10,11,12,13,14,15]'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      # ROBUST ENCODER: 1 byte -> 4 complex symbols
      # k = 8 bits, n = 4 complex symbols

      import numpy as np
      import os
      import sys
      import tensorflow as tf
      from gnuradio import gr

      _PROJECT_DIRS = [
          r'N:\SEM-6\SDR\ASSIGNMENT\SDR ASSIGNMENT\SDR ASSIGNMENT',
          '/n/SEM-6/SDR/ASSIGNMENT/SDR ASSIGNMENT/SDR ASSIGNMENT',
          '.',
          os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
      ]

      _PROJECT_DIR = next((p for p in _PROJECT_DIRS if os.path.exists(os.path.join(p, 'models'))), '.')
      _MODELS_DIR  = os.path.join(_PROJECT_DIR, 'models')

      for _p in [_PROJECT_DIR, _MODELS_DIR]:
          if _p not in sys.path:
              sys.path.insert(0, _p)

      try:
          from autoencoder import CUSTOM_OBJECTS
      except ImportError:
          CUSTOM_OBJECTS = {}

      class blk(gr.basic_block):

          def __init__(self, model_path=os.path.join(_PROJECT_DIR,'flat_fading_results','encoder_fading.keras')):
              gr.basic_block.__init__(
                  self,
                  name='ML Encoder',
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )

              self.k = 8   # 8 bits input
              self.n = 4   # 4 complex symbols output

              candidates = [
                  os.path.join(_PROJECT_DIR,'flat_fading_results','encoder_fading.keras'),
                  os.path.join(_PROJECT_DIR,'saved_models','encoder_fading.keras'),
                  model_path,
              ]

              resolved = next((p for p in candidates if p and os.path.exists(p)), None)

              if resolved is None:
                  raise FileNotFoundError(
                      '[ML Encoder] No model found. Run: cd models && python train.py --k 8 --use_fading'
                  )

              print(f'[ML Encoder] Loading: {resolved}')

              self.encoder = tf.keras.models.load_model(
                  resolved,
                  compile=False,
                  custom_objects=CUSTOM_OBJECTS
              )

              print(f'[ML Encoder] Ready ({self.k} bits -> {self.n} symbols)')


          def general_work(self, input_items, output_items):

              in_bytes = input_items[0]
              out_symbols = output_items[0]

              n_process = min(len(in_bytes), len(out_symbols) // self.n)

              if n_process == 0:
                  return 0

              bits_batch = np.array([
                  [int(b) for b in format(int(v) & 0xFF, '08b')]
                  for v in in_bytes[:n_process]
              ], dtype=np.float32)

              encoded = self.encoder.predict(bits_batch, verbose=0)

              out_symbols[:n_process * self.n] = encoded.flatten()

              self.consume(0, n_process)

              return n_process * self.n
    model_path: '""'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      # ML NEURAL NETWORK DECODER: Uses decoder.keras directly
      # k = 8 bits (values 0-255)

      import numpy as np
      from gnuradio import gr
      import tensorflow as tf
      import sys, os

      _PROJECT_DIRS = [
          r'N:\SEM-6\SDR\ASSIGNMENT\SDR ASSIGNMENT\SDR ASSIGNMENT',
          '/n/SEM-6/SDR/ASSIGNMENT/SDR ASSIGNMENT/SDR ASSIGNMENT',
          '.',
          os.path.dirname(os.path.abspath(__file__)) if '__file__' in locals() else '.'
      ]

      _PROJECT_DIR = next((p for p in _PROJECT_DIRS if os.path.exists(os.path.join(p, 'models'))), '.')
      _MODELS_DIR  = os.path.join(_PROJECT_DIR, 'models')

      for _p in [_PROJECT_DIR, _MODELS_DIR]:
          if _p not in sys.path:
              sys.path.insert(0, _p)

      try:
          from autoencoder import CUSTOM_OBJECTS
      except ImportError:
          CUSTOM_OBJECTS = {}

      class blk(gr.basic_block):

          def __init__(self, model_path=os.path.join(_PROJECT_DIR,'flat_fading_results','decoder_fading.keras')):
              gr.basic_block.__init__(
                  self,
                  name='ML Decoder NN',
                  in_sig=[np.complex64],
                  out_sig=[np.uint8]
              )

              self.k = 8   # 8 bits output
              self.n = 4   # 4 complex symbols input
              self._buffer = []

              candidates = [
                  os.path.join(_PROJECT_DIR,'flat_fading_results','decoder_fading.keras'),
                  os.path.join(_PROJECT_DIR,'saved_models','decoder_fading.keras'),
                  model_path,
              ]

              resolved = next((p for p in candidates if p and os.path.exists(p)), None)

              if resolved is None:
                  raise FileNotFoundError(
                      '[ML Decoder] No model found. Run: cd models && python train.py --k 8 --use_fading'
                  )

              print(f'[ML Decoder] Loading: {resolved}')

              self.decoder = tf.keras.models.load_model(
                  resolved,
                  compile=False,
                  custom_objects=CUSTOM_OBJECTS
              )

              print(f'[ML Decoder] Ready ({self.n} symbols -> {self.k} bits)')


          def _bits_to_byte(self, bit_probs):
              return int(''.join(map(str, np.round(bit_probs).astype(int))), 2)


          def general_work(self, input_items, output_items):

              in_syms = input_items[0]
              out_bytes = output_items[0]

              if len(in_syms) > 0:
                  self._buffer.extend(in_syms.tolist())
                  self.consume(0, len(in_syms))

              n_process = min(len(self._buffer) // self.n, len(out_bytes))

              if n_process == 0:
                  return 0

              symbols = np.array(
                  self._buffer[:n_process * self.n],
                  dtype=np.complex64
              ).reshape(n_process, self.n)

              bit_probs = self.decoder.predict(symbols, verbose=0)  # (n_process, 8)

              for i in range(n_process):
                  out_bytes[i] = np.uint8(self._bits_to_byte(bit_probs[i]))

              self._buffer = self._buffer[n_process * self.n:]

              return n_process
    model_path: '""'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import tensorflow as tf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '16'
    ymin: '0'
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0, '0', blocks_char_to_float_0, '0']
- [blocks_delay_0, '0', epy_block_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_float_to_complex_0_0, '0', qtgui_const_sink_x_0, '1']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [channels_channel_model_0, '0', epy_block_1, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0_0, '0']
- [epy_block_0, '0', channels_channel_model_0, '0']
- [epy_block_1, '0', blocks_char_to_float_0_0, '0']
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', blocks_vector_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
